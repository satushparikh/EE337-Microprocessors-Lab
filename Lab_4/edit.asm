ORG 0H
LJMP MAIN

ORG 100H
MAIN:
CALL QUANT
HERE: SJMP HERE

ORG 130H
QUANT:
MOV R5,#05
MOV R4,#04H   
MOV R0 , #60H

LOO:  
MOV A ,@R0
CLR C  
SUBB A,#30
JNC OUT35

MOV A ,@R0 
MOV B,#10
DIV AB

MOV B,#10
MUL AB 

ADD A,R5 

SJMP UPDATE

OUT35:
MOV A,#35

UPDATE:
MOV @R0,A 
INC R0 
DJNZ R4, LOO

MOV R0,#60H 
MOV R1,#70H 
MOV R6,#08H

ANSWER:
MOV A,@R0                
MOV @R1,A    
      
INC R0
INC R1    
DJNZ R6, ANSWER

RET
END
