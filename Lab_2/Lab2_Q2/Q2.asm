;// -- DO NOT CHANGE ANYTHING UNTIL THE **** LINE--//
ORG 0H
LJMP MAIN
ORG 100H
MAIN:
CALL DET
HERE: SJMP HERE
ORG 130H
;// *****************
DET:

; MOV 60H,#056H
; MOV 61H,#012H
; MOV 62H,#03AH
; MOV 63H,#02CH

MOV 60H,#034H
MOV 61H,#0E1H
MOV 62H,#059H
MOV 63H,#0D0H


MOV A,61H
MOV B,62H
MUL AB;LOWER BYTE IN A & UPPER BYTE IN B
MOV R1,B
MOV R0,A     

MOV A,60H
MOV B,63H
MUL AB;LOWER BYTE IN A & UPPER BYTE IN B
MOV R3,B
; MOV R0,A;REDUNDANT
CLR C 
SUBB A,R0;SUBTRACTING LOWER BITS
MOV 71H,A  

MOV A,R3 
SUBB A,R1    
MOV 70H,A    



;// ADD YOUR CODE HERE
RET
END