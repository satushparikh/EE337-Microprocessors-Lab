# Keil uVision project LAB2_Q1_again.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C5131A Microchip
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(32000000) MODP2
  output: LAB2_Q1_again
  c flags: Optimize=8 SizeSpeed=1
